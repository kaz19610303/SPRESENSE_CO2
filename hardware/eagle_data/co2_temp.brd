# Repository kaz19610303/SPRESENSE_CO2

File README.md:

# SPRESENSE_CO2
CO2,temperature and humidity sensores bord for SPRESENSE.

CPUボード  
[Sony SPRESENSE](https://developer.sony.com/ja/develop/spresense/)

使用センサー  
|センサー|メーカー|データシート
|:----|:----|:----|
| SGP30-2.5K | Sensirion | https://www.mouser.jp/datasheet/2/682/Sensirion_Gas_Sensors_SGP30_Datasheet-1843629.pdf |
| SHTC1 | Sensirion | https://www.mouser.jp/datasheet/2/682/Sensirion_Humidity_Sensors_SHTC1_Datasheet-1511754.pdf |

プロラム開発環境  
[Spresense Arduino](https://developer.sony.com/develop/spresense/docs/arduino_set_up_ja.html)

参考  
[Sony Spresense LTE拡張ボードで温湿度、eCO2、TVOCのデータをCloud(Thingspeak)にアップロード](https://qiita.com/kaz19610303/items/e653e129437775d22272)

## EAGLE design hardware/eagle_data/co2_temp.brd

Parts:
C1, C3: 0.1uF; 0603
C2: 10uF; 0603
IC1: SHTC1; SON100P200X200X7500-5N
IC2: SGP30-2.5K; SON80P245X245X90-7N
J1, J2: 4p-2.54; H4-2.54

Connections:
1.8V: C1.1, C2.1, C3.1, IC1.1 (VDD), IC2.1 (VDO), IC2.5 (VDOH), J1.2
GND: C1.2, C2.2, C3.2, IC1.4 (VSS), IC1.5 (EP), IC2.2 (VSS), IC2.4 (R), IC2.7 (EP), J2.1
I2C_SCL: IC1.2 (SCL), IC2.6 (SCL), J2.2
I2C_SDA: IC1.3 (SDA), IC2.3 (SDA), J2.3

Notes on the sheet:
SGP30&SHTC1 Board for Spresense
Next Step LLC
https://next-step.asia
NS-SPR-0308

Board: 2 copper layers, 20.6 x 10.5 mm, 7 parts (0 on the bottom side), 4 nets.

## EAGLE design hardware/eagle_data/mh-z19b.brd

Parts:
C1, C2, C3: 4.7uF; C0603K
C4, C8: 1uF; C0603K
C9, C20: 0.1uF; C0603K
IC1: SHT30-DIS-B2.5KS; SHT30DISB25KS
IC3: MCP1700T-3302E_TT; SOT95P237X112-3N
IC4: TXB0106RGYR; SN74CBT3257CRGYR
J5: MH-Z19-CO2-NDIR-SENSOR; MH-Z19
JP1, JP2, JP3: JUMPER-SMT_3_NO_NO-SILK; SMT-JUMPER_3_NO_NO-SILK
JP4, JP5: JUMPER-SMT_2_NC_PASTE_NO-SILK; SMT-JUMPER_2_NC_PASTE_NO-SILK
R1, R2, R5, R6: 10k; R0603
SV1, SV2: FE13-1; FE13
SW1: B3U-1000PM; B3U1000PM

Connections:
1V8: C1.2, IC4.2 (VCCA), IC4.8 (OE), SV2.2
1V8*: SV1.11
3.3V: C2.1, C3.2, C8.1, C9.1, C20.2, IC1.5 (VDD), IC3.2 (VOUT), IC4.15 (VCCB), J5.6 (VIN), JP3.1, JP4.2
+3V3*: SV1.10
CTS: JP2.3, SV1.5
EMMC_DATA2: JP2.1, SV2.5
EMMC_DATA3: JP1.1, SV2.4
EXT_VDD: C4.1, IC3.3 (VIN), SV2.3
GND: C1.1, C2.2, C3.1, C4.2, C8.2, C9.2, C20.1, IC1.7 (R), IC1.8 (VSS), IC1.9 (EP), IC3.1 (GND), IC4.9 (GND), IC4.17 (EP), J5.7 (GND), JP3.3, SV1.1, SV2.10, SW1.1 (COM)
HD: IC4.11 (B5), J5.5 (HD), SW1.2 (NO)
I2C_SCL: IC4.1 (A1), R1.1, SV2.11
I2C_SDA: IC4.7 (A6), R2.1, SV2.12
I2S_BCK: SV1.6
I2S_DIN: SV2.6
I2S_DOUT: SV2.7
I2S_LRCK: SV1.7
unnamed: IC4.5 (A4), JP1.2
unnamed: IC4.6 (A5), JP2.2
unnamed: JP4.1, R5.2, R6.2
unnamed: JP5.1, R1.2, R2.2
unnamed: IC1.2 (ADDR), JP3.2
PWM: IC4.12 (B4), J5.9 (PWM)
RTS: JP1.3, SV1.4
RX: IC4.4 (A3), SV1.3
RX1: IC4.13 (B3), J5.3 (TX)
SCL: IC1.4 (SCL), IC4.16 (B1), R5.1
SDA: IC1.1 (SDA), IC4.10 (B6), R6.1
SEN_AIN4: SV1.13
SEN_AIN5: SV2.13
SEN_IRQ_IN: SV1.12
SPI_CS: SV1.8
SPI_MISO: SV2.8
SPI_MOSI: SV2.9
SPI_SCK: SV1.9
TX: IC4.3 (A2), SV1.2
TX1: IC4.14 (B2), J5.2 (RX)
VCCIO: JP5.2
VO: J5.1 (VO)
XRST_PIN_1.8V: SV2.1

Notes on the sheet:
1.8V ⇔ 3.3V レベルコンバーター
スタッカブル用
Co2 Temp Hum sensors board
Sony Spresense
NS-SPR-0306

Board: 2 copper layers, 21.6 x 37.8 mm, 23 parts (5 on the bottom side), 23 nets.

## Commit log

2020-11-17 hardware first commit
2021-01-11 Test program,BOM

Notices in the files:
parts and their libraries:
SparkFun-Capacitors: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
